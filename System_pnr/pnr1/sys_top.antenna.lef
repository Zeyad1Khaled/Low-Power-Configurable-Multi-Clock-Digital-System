

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO sys_top 
  PIN REF_CLK 
    ANTENNAPARTIALMETALAREA 0.619 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.97739 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 3.584 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.4314 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 1.30521 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 6.36099 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.0235732 LAYER VIA34 ;
  END REF_CLK
  PIN UART_CLK 
    ANTENNAPARTIALMETALAREA 0.351 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.68831 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.632 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.23232 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.796 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.02116 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 0.628053 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 3.16668 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.0353598 LAYER VIA45 ;
  END UART_CLK
  PIN RST_N 
    ANTENNAPARTIALMETALAREA 1.853 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.10533 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 5.716 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.6864 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 112.983 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 547.202 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.3546 LAYER VIA34 ;
  END RST_N
  PIN UART_RX_IN 
    ANTENNAPARTIALMETALAREA 7.21 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 34.8725 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 23.555 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 113.684 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2808 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 156.18 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 753.509 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.05698 LAYER VIA34 ;
  END UART_RX_IN
  PIN scan_clk 
    ANTENNAPARTIALMETALAREA 0.255 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.22655 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 2.19 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.7263 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 1.206 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.99326 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 0.78869 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 3.93935 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.0353598 LAYER VIA45 ;
  END scan_clk
  PIN scan_rst 
    ANTENNAPARTIALMETALAREA 1.429 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 7.06589 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 3.511 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.0803 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.859 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.51659 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 106.567 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 530.778 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 4.06379 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 2.764 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 13.4872 LAYER METAL5 ;
    ANTENNAGATEAREA 0.2665 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 116.938 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 581.387 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 4.06379 LAYER VIA56 ;
  END scan_rst
  PIN test_mode 
    ANTENNAPARTIALMETALAREA 10.209 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 49.1053 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 14.16 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 69.6488 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.8395 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 44.2088 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 213.732 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.05698 LAYER VIA34 ;
  END test_mode
  PIN SE 
    ANTENNAPARTIALMETALAREA 1.362 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.55122 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.268 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.48148 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 13.174 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 63.5593 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.6159 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 45.929 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 224.563 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.62805 LAYER VIA56 ;
  END SE
  PIN SI[3] 
    ANTENNAPARTIALMETALAREA 3.052 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 14.6801 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.168 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.00048 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 3.935 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.1198 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 26.239 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 126.402 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNAPARTIALMETALAREA 15.333 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 73.9441 LAYER METAL6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL6 ; 
    ANTENNAMAXAREACAR 307.542 LAYER METAL6 ;
    ANTENNAMAXSIDEAREACAR 1493.86 LAYER METAL6 ;
    ANTENNAMAXCUTCAR 3.38649 LAYER VIA67 ;
  END SI[3]
  PIN SI[2] 
    ANTENNAPARTIALMETALAREA 5.303 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 25.5074 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.065 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.31505 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 43.5891 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 210.134 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.3546 LAYER VIA34 ;
  END SI[2]
  PIN SI[1] 
    ANTENNAPARTIALMETALAREA 7.301 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 35.3102 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 139.599 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 674.432 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.677298 LAYER VIA23 ;
  END SI[1]
  PIN SI[0] 
    ANTENNAPARTIALMETALAREA 0.647 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.11207 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 11.998 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 57.9028 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.268 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.48148 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 0.168 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.00048 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNAPARTIALMETALAREA 20.194 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 97.3256 LAYER METAL6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL6 ; 
    ANTENNAMAXAREACAR 462.789 LAYER METAL6 ;
    ANTENNAMAXSIDEAREACAR 2243.41 LAYER METAL6 ;
    ANTENNAMAXCUTCAR 5.41839 LAYER VIA67 ;
  END SI[0]
  PIN SO[3] 
    ANTENNAPARTIALMETALAREA 6.251 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 30.0673 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 6.805 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 32.9245 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 16.176 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 77.999 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNAPARTIALMETALAREA 0.7678 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.88119 LAYER METAL6 ;
    ANTENNAPARTIALCUTAREA 0.2592 LAYER VIA67 ;
    ANTENNADIFFAREA 0.537 LAYER METAL7 ; 
    ANTENNAPARTIALMETALAREA 23.224 LAYER METAL7 ;
    ANTENNAPARTIALMETALSIDEAREA 136.796 LAYER METAL7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1235 LAYER METAL7 ; 
    ANTENNAMAXAREACAR 262.841 LAYER METAL7 ;
    ANTENNAMAXSIDEAREACAR 1465.7 LAYER METAL7 ;
  END SO[3]
  PIN SO[2] 
    ANTENNAPARTIALMETALAREA 7.544 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 36.2866 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNADIFFAREA 0.537 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 6.804 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 33.112 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1326 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 203.876 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 986.243 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 4.04968 LAYER VIA45 ;
  END SO[2]
  PIN SO[1] 
    ANTENNAPARTIALMETALAREA 4.177 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 20.0914 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.25 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3949 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 10.272 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 49.6007 LAYER METAL5 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA56 ;
    ANTENNADIFFAREA 0.6 LAYER METAL6 ; 
    ANTENNAPARTIALMETALAREA 12.477 LAYER METAL6 ;
    ANTENNAPARTIALMETALSIDEAREA 60.2068 LAYER METAL6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9672 LAYER METAL6 ; 
    ANTENNAMAXAREACAR 73.8657 LAYER METAL6 ;
    ANTENNAMAXSIDEAREACAR 357.597 LAYER METAL6 ;
    ANTENNAMAXCUTCAR 2.28677 LAYER VIA67 ;
  END SO[1]
  PIN SO[0] 
    ANTENNAPARTIALMETALAREA 3.409 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.3973 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNADIFFAREA 0.401 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 16.495 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 79.5334 LAYER METAL4 ;
  END SO[0]
  PIN UART_TX_O 
    ANTENNAPARTIALMETALAREA 37.196 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 179.105 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNADIFFAREA 0.586 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 5.343 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 25.8922 LAYER METAL4 ;
  END UART_TX_O
  PIN parity_error 
    ANTENNAPARTIALMETALAREA 29.352 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 141.183 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 2.846 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.8817 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNADIFFAREA 0.6 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 7.32 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 35.4016 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.169 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 93.8541 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 451.355 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 2.20903 LAYER VIA56 ;
  END parity_error
  PIN framing_error 
    ANTENNADIFFAREA 0.6 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 34.764 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 167.215 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1599 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 306.433 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 1471.93 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.05698 LAYER VIA34 ;
  END framing_error
END sys_top

END LIBRARY
